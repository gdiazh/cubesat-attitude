Commit message: added velocity controllers

File: cube_pillars/urdf/cube_pillars.urdf (robot description, URDF)
Before this commit: robot cube_pillars, 6 links, 5 joints
Links:
- link base_global_link: mass 0.59402 -> 200.59402
